LICENSE = "GPLv2 | GPLv3"
