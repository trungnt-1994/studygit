DEPENDS = "libpng libjpeg-turbo"

EXTRA_OECONF = "--without-libungif"
